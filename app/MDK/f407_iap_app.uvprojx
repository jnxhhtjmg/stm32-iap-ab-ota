# Keil uVision project f407_iap_app.uvprojx, settings and files
target app_slot_a (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: app_slot_a +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: STM32F407xx,VECT_TAB_OFFSET=0x8000
  c include: ../Inc;../../bootloader/Inc;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x800C000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group App
    ./: startup_stm32f407xx.s
    ../Src/: main.c oled.c system_stm32f4xx.c
target app_slot_b (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  cpu: as above
  output: app_slot_b +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: STM32F407xx,VECT_TAB_OFFSET=0x40000
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
target app_slot_b_bad (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  cpu: as above
  output: app_slot_b_bad +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: STM32F407xx,VECT_TAB_OFFSET=0x40000,APP_NEVER_CONFIRM=1
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
software components: CMSIS:CORE 5.0.1
