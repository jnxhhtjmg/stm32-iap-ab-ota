# Keil uVision project f407_iap_boot.uvprojx, settings and files
target f407_iap_boot (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: f407_iap_boot +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: STM32F407xx
  c include: ../Inc;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x8000
  group Boot
    ./: startup_stm32f407xx.s
    ../Src/: main.c ab_api.c ab_flash.c ab_image.c ab_meta.c ab_proto.c ab_uart.c ab_util.c ab_sig.c ab_pubkey.c tweetnacl.c system_stm32f4xx.c
software components: CMSIS:CORE 5.0.1
